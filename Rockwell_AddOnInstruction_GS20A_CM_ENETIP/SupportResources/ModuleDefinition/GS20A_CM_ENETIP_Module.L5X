(* Logix 5000 Module export GS20A_CM_ENETIP; software revision 37.00 *)

MODULES
   GS20A_CM_ENETIP : GS20A-CM-ENETIP (Ethernet 10.11.0.51, rev 1.1, StandardDataDriven RPI 250 ms)
END_MODULES
